Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-01-03T12:17:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 03 12:17:12 2024 * Host: ZILBY3SGS3 * Database: C:\Users\SMalaya\AppData\Local\Temp\4140963f-f690-4caf-b858-7c1e06c70107\80f10cf0-8f1b-421a-9ba5-9a653f4da604\ifc * Database version: 5507 * Database creation date: Wed Jan 03 12:17:11 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 03 12:17:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 03 12:17:12 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: SB242-24RL-J:SB242-24RL-J, SB242-24RL-J:SB242-24RL-J:763104
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: SB242-24RL-J
Pset_DistributionFlowElementCommon - Reference: SB242-24RL-J; sets with these values: 2
